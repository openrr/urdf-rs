Commit message: Try to support serialize

File: sample.urdf (robot description, URDF)
Before this commit: robot robo, 7 links, 6 joints
Links:
- link root: mass 1 -> 1.5
